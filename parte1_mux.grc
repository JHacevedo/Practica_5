options:
  parameters:
    generate_options: qt_gui
    id: mux_three_sig
    output_language: python
    title: mux three signals
  states: {}

blocks:
- name: d1
  id: variable_qtgui_range
  parameters:
    label: delay 1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: d2
  id: variable_qtgui_range
  parameters:
    label: delay 2
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: d3
  id: variable_qtgui_range
  parameters:
    label: delay 3
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: ancho de pulso
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: Modulador_PAM_0
  id: Modulador_PAM
  parameters:
    d: '0'
    fs: '0'
    samp_rate: 100e3
  states: {}
- name: Modulador_PAM_0_0
  id: Modulador_PAM
  parameters:
    d: '0'
    fs: '0'
    samp_rate: 100e3
  states: {}
- name: Modulador_PAM_0_0_0
  id: Modulador_PAM
  parameters:
    d: '0'
    fs: '0'
    samp_rate: 100e3
  states: {}
- name: Modulador_PAM_0_0_0_0
  id: Modulador_PAM
  parameters:
    d: '0'
    fs: '0'
    samp_rate: 100e3
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_2_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_2_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: d3
    type: float
  states: {}
- name: blocks_delay_0_0_1_0
  id: blocks_delay
  parameters:
    delay: d2
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: d1
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Modulador_PAM_0, '0', blocks_add_xx_0_0_0, '0']
- [Modulador_PAM_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [Modulador_PAM_0_0, '0', blocks_delay_0_1_0, '0']
- [Modulador_PAM_0_0_0, '0', blocks_delay_0_0_1_0, '0']
- [Modulador_PAM_0_0_0_0, '0', blocks_delay_0_0_0_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', Modulador_PAM_0, '0']
- [analog_sig_source_x_1_0_0, '0', Modulador_PAM_0_0, '0']
- [analog_sig_source_x_2_0_0_0, '0', Modulador_PAM_0_0_0_0, '0']
- [analog_sig_source_x_2_1_0, '0', Modulador_PAM_0_0_0, '0']
- [blocks_add_xx_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_add_xx_0_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_delay_0_0_0_0_0, '0', blocks_add_xx_0_0_0, '3']
- [blocks_delay_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0, '3']
- [blocks_delay_0_0_1_0, '0', blocks_add_xx_0_0_0, '2']
- [blocks_delay_0_0_1_0, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_delay_0_1_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_delay_0_1_0, '0', qtgui_time_sink_x_0_0_0, '1']

metadata:
  file_format: 1
